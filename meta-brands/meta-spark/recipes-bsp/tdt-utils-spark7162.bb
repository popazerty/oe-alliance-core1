require tdt-utils.inc

PR = "${INC_PR}.1"

RPROVIDES_${PN} = " \
        evremote2 \
        fp_control \
        libmmeimage \
        stfbcontrol \
        ustslave \
	"
