require tdt-utils.inc

